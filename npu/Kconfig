## npu/Kconfig
```kconfig
# SPDX-License-Identifier: GPL-2.0
#
# NPU Configuration
#

config NPU
    bool "NPU SUPPORT"
    help
        Support NPU Driver for openedges
```
